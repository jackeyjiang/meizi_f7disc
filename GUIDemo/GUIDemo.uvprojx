# Keil uVision project GUIDemo.uvprojx, settings and files
target STM32F746 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STM32746G_DISCOVERY
  c misc: --gnu
  c include: .\FatFs\src;.\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c app.cpp
  group Documentation
    ./: Abstract.txt
  group emwin_task\smarthome
    ./emwin_task/smarthome/: appliance.c camera.c curtain.c dialogue.c home.c light.c microphone.c music.c safety.c sound.c video.c monitor.c set.c App_SysFunction.c MainTask.c MainTask_R.c Yahei.c
  group emwin_task\smarthome\light
    ./emwin_task/smarthome/light/: light_bulb.c LigthControlDLG.c next.c on_off.c return.c upon.c
  group emwin_task\smarthome\fdm
    ./emwin_task/smarthome/fdm/: FdmDLG.c GUIDEMO_Resource.c DIALOG_FS_ChooseFile.c Getline.c File_Demo.c FileDialogDLG.c filelist.c
  group emwin_task\smarthome\fdm\index
    ./emwin_task/smarthome/fdm/: commu.cpp Eeprom.cpp Gcode.cpp m_Print.cpp m_serial.cpp sdReader.cpp stepMoto.cpp temperature.cpp melzi.cpp m_gpio.cpp m_pins.cpp m_nvic.cpp m_exti.cpp m_timer.cpp m_sysConf.cpp
  group emwin_task\smarthome\fdm\picture
    ./emwin_task/smarthome/fdm/picture/tool/: Tool_auto_leveling_xg.c Tool_manual_leveling_xg.c Tool_manual_xg.c
    ./emwin_task/smarthome/fdm/picture/system/: Sys_default_xg.c Sys_info_xg.c Sys_moniter_xg.c Sys_return_xg.c
    ./emwin_task/smarthome/fdm/picture/printset/: Print_image.c Print_pause_xg.c Print_set_dec_xg.c Print_set_inc_xg.c Print_set_xg.c Print_start_xg.c Print_stop_xg.c
    ./emwin_task/smarthome/fdm/picture/manual/: manual_0_1_xg.c manual_1_xg.c manual_10_xg.c manual_bed_tmp_dec_xg.c manual_bed_tmp_inc_xg.c manual_celsius.c manual_dwon_xg.c manual_e_dec_xg.c manual_e_inc_xg.c manual_extruder_tmp_dec_xg.c manual_extruder_tmp_inc_xg.c manual_home_xg.c manual_left_xg.c manual_return_xg.c manual_right_xg.c manual_up_xg.c manual_z_dec_xg.c manual_z_inc_xg.c
  group emwin_task\smarthome\fdm\app
    ./emwin_task/smarthome/fdm/App/: cloudprint_dialog.c file_brower.c manual_control.c prinf_file_true.c print_choose.c print_choose_ascii.c print_stop_warning.c sys_setdefault.c system_set.c tool_choose.c wifi_dialog.c
  group emwin_task\smarthome\fdm\appl
    ./emwin_task/smarthome/fdm/App/: ManualCtrlPageDLG.c SysPageDLG.c TemperatureWavePageDLG.c ToolsPageDLG.c
    ./emwin_task/smarthome/fdm/: WIDGET_ListWheel.c PrintingDLG.cpp
  group Linker script
    ./: GUIDemo.sct
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, File System:CORE 6.5.0, File System:Drive:Memory Card 6.5.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:SD 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Drivers:Touch Screen 1.0.0, Board Support:LED 1.0.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:MCI 1.3, Compiler:I/O:File 1.0.0, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Compiler:I/O:TTY 1.0.0, Device:STM32Cube Framework:Classic 1.0.0, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:DMA2D 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:I2C 1.0.1, Device:STM32Cube HAL:LTDC 1.0.1, Device:STM32Cube HAL:PWR 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:STM32Cube HAL:SD 1.0.1, Device:STM32Cube HAL:SDRAM 1.0.1, Device:STM32Cube HAL:UART 1.0.1, Device:Startup 1.0.1, Graphics Display:STM32F746G-Discovery 1.0.0, Graphics:CORE 5.30.0, Graphics:Input Device:Touchscreen 5.30.0
